# Keil uVision project main.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: XLZN +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD
  c misc: --c99
  c include: ..\System\delay;..\System\sys;..\System\usart;..\Hardware\LED;..\Hardware\KEY;..\Hardware\OLED;..\Hardware\ADC;..\Hardware\MOTOR;..\Hardware\DMP;..\Hardware\PS2;..\Hardware\ENCODER;..\Hardware\DMA
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: startup_stm32f10x_md.s
  group Hardware
    ../Hardware/ADC/: adc.c
    ../Hardware/KEY/: key.c
    ../Hardware/LED/: LED.C
    ../Hardware/MOTOR/: motor.c
    ../Hardware/OLED/: oled.c
    ../Hardware/ENCODER/: encoder.c
    ../Hardware/DMA/: DMA.c
  group System
    ../System/delay/: delay.c
    ../System/sys/: sys.c
    ../System/usart/: usart.c
  group User
    ./: main.c
software components: CMSIS:CORE 5.1.2
