# Keil uVision project BH-F103.uvprojx, settings and files
target OLED_SD1306 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OLED_SD1306 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\inc;..\..\User\oled;..\..\User\systick;..\..\User\led;..\..\User\usart;..\..\Libraries\src;..\..\User\MPU6050\eMPL;..\..\User\MPU6050;..\..\SYSTEM\sys;..\..\SYSTEM\delay;..\..\SYSTEM\usart;..\..\User\OLED;..\..\User\EXTI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/systick/: bsp_SysTick.c
    ../../User/bluetooth/: bluetooth.c
    ../../User/encode/: encode.c
    ../../User/LED/: led.c
    ../../User/motor/: motor.c
    ../../User/MPU6050/: mpu6050.c mpuiic.c
    ../../User/MPU6050/eMPL/: inv_mpu_dmp_motion_driver.c inv_mpu.c
    ../../User/pid/: pid .c
    ../../User/OLED/: oled.c
    ../../User/EXTI/: exti.c
  group DOC
    ../../Doc/: Readme.txt
  group SYSTEM
    ../../SYSTEM/sys/: sys.c
    ../../SYSTEM/delay/: delay.c
    ../../SYSTEM/usart/: usart.c
